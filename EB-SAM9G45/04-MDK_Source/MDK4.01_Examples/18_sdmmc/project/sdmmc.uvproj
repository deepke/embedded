# Keil uVision project sdmmc.uvproj, settings and files
target RUN_IN_DDRAM (ARM-ADS)
  device: AT91SAM9G45 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(12000000) CPUTYPE(ARM926EJ-S)
  output: sdmmc
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1
  c define: at91sam9g45 ddram NOFPUT  TRACE_LEVEL=4  ORIGIN_SD_PORT_MCI1
  c misc: --gnu
  c include: ..\..\common\at91lib;..\..\common\at91lib\boards;..\..\common\at91lib\boards\at91sam9g45;..\..\common\at91lib\drivers;..\..\common\at91lib\memories;..\..\common\at91lib\peripherals;..\..\common\at91lib\drivers\crc
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: ..\..\common\at91lib\boards\at91sam9g45\ddram.sct
  link misc: --entry resetHandler
  group startup
    ../../common/at91lib/boards/: board_cstartup_keil.s
  group at91lib
    ../../common/at91lib/boards/: board_lowlevel.c board_memories.c
    ../../common/at91lib/drivers/dmad/: dmad.c
    ../../common/at91lib/memories/sdmmc/: sdmmc_mci.c
    ../../common/at91lib/peripherals/cp15/: cp15.c cp15_asm_keil.s
    ../../common/at91lib/peripherals/dbgu/: dbgu.c
    ../../common/at91lib/peripherals/dma/: dma.c
    ../../common/at91lib/peripherals/irq/: aic.c
    ../../common/at91lib/peripherals/mci/: mci_hs.c
    ../../common/at91lib/peripherals/pio/: pio.c
    ../../common/at91lib/peripherals/pmc/: pmc.c
    ../../common/at91lib/peripherals/tc/: tc.c
    ../../common/at91lib/utility/: trace.c retarget.c
  group user
    ../src/: main.c
  group Readme
    ../Readme/: Readme.txt
